# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L011F4Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L011xx
  c include: ..\SYSTEM\init;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;.\drivers
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --keep *.o(.jesse_fn.*)
  group STARTUP
    ./: startup_stm32l011xx.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/init/: jesse_init.c
    ./drivers/: jesse_usart2.c
  group README
    ../: readme.txt
